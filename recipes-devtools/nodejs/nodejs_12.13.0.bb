require nodejs_12.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=be4d5107c64dc3d7c57e3797e1a0674b"

SRC_URI[src.md5sum] = "e51c71cf24a370c54ec6266236ab3ff4"
SRC_URI[src.sha256sum] = "2e5321e095fe673a3ab936cf77faf8c983cba62f27a9fbd00530a7edb739a040"

#PACKAGECONFIG_append = " openssl zlib"
